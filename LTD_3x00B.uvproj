# Keil uVision project LTD_3x00B.uvproj, settings and files
target LTD_3x00B (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: LTD_3x00B +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: a96l41x_adc.c a96l41x_clock.c a96l41x_gpio.c a96l41x_opamp.c a96l41x_timer0.c a96l41x_timer1.c a96l41x_timer2.c a96l41x_usart.c a96l41x_usart_spi.c audio.c delay.c flash.c main.c calib.c a96l41x_dataflash.c
  group startup
    ./: startup.a51
  group inc
    ./src/: a96l41x.h a96l41x_adc.h a96l41x_clock.h a96l41x_gpio.h a96l41x_opamp.h a96l41x_timer0.h a96l41x_timer1.h a96l41x_timer2.h a96l41x_usart.h a96l41x_usart_spi.h audio.h delay.h flash.h main.h sound_fire1.h typedef.h calib.h a96l41x_dataflash.h
