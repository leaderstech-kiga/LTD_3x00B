# Keil uVision project Stand_along_Abov.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: Stand_along_Abov +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source
    ./src/: a96l41x_adc.c a96l41x_clock.c a96l41x_gpio.c a96l41x_opamp.c a96l41x_timer0.c a96l41x_timer1.c a96l41x_timer2.c a96l41x_usart.c a96l41x_usart_spi.c audio.c delay.c flash.c main.c
  group StartUp
    ./: startup.a51
