# Keil uVision project A96L41x_DataFlash.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: A96L41x_DataFlash +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: Main.c delay.c a96l41x_clock.c a96l41x_dataflash.c a96l41x_gpio.c
  group STARTUP
    ./src/: STARTUP.A51
